# Autodesk Inventor part: DM931_DN80
## iProperties
Created: 2011-02
Part Number: DM931_DN80
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
